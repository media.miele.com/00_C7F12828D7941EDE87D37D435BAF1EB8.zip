Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-07-06T14:31:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 06 14:31:53 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\11c388f3-7a05-477c-a34e-551da06a8964\9d0091f8-f714-462a-b543-73d69e5d4e45\ifc * Database version: 5507 * Database creation date: Thu Jul 06 14:31:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 06 14:31:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 06 14:31:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12387540_BR_DGC7640_EDST-CLST:23764042_BR_12387540_DGC7640_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 23764042_BR_12387540_DGC7640_EDST-CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 23764042_BR_12387540_DGC7640_EDST-CLST
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - sets with these values: 2
